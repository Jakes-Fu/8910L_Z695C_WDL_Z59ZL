/*****************************************************************************
** File Name:       dhcps_test.c
** Author:          lisa.lin
** Date:            2011/08/12
** Copyright:       2011 Spreadtrum, Incorporated. All Rights Reserved.      
** Description:     dhcp server test
******************************************************************************
**                         Important Edit History                            *
** --------------------------------------------------------------------------*
** DATE             NAME                DESCRIPTION                          
** 2011/08/12       lisa.lin            create
******************************************************************************/

/*---------------------------------------------------------------------------*
 *                          Include Files                                    *
 *---------------------------------------------------------------------------*/
#include "app_tcp_if.h"
#include "dhcps_api.h"
#include "tcpip_api.h"
#include "ipport.h"
#include "dhcps_common.h"
#include "dhcps_test.h"

#if 0
void DHCPS_Test_SetParam(void)
{
   DHCP_SERVER_CONFIG_T server_param ={0};
    //strcpy(server_param.subnet_mask,"200.200.001.143");
    //strcpy(server_param.router,"144.200.34.5");
   // strcpy(server_param.dns1,"172.23.4.10");
   // strcpy(server_param.dns2,"176.23.4.11");
        server_param.subnet_mask = htonl(0xFFFFFF01);
        server_param.router = htonl(0xaca80001);
        server_param.dns1 = htonl(0xac100086);
        server_param.dns2 = htonl(0xac100087);
        server_param.lease_time = 5905; 
    
    DHCPS_SetServerParam(&server_param);
    {
        uint8 mac_src1[6] = {0x00,0x05,0x7F,0x60,0xe9,0x3b};
        uint32 nip1=htonl(0xbd901309);
        
        //�Ѿ���
        uint8 mac_src2[6] ={0x00,0x50,0x08,0x10,0xED,0x5F};    
        uint32 nip2=htonl(0xFFFEF700);

        uint8 mac_src3[6] = {0x00,0x06,0x18,0x50,0xf4,0x6f};
        uint32 nip3=htonl(0xbc891004);
               
        
        DHCPS_AddStaticLease(mac_src1, nip1);
        DHCPS_AddStaticLease(mac_src2, nip2);
        DHCPS_AddStaticLease(mac_src3, nip3);

        DHCPS_DelStaticLease(mac_src1);
        DHCPS_DelStaticLease(mac_src2);
    }
}

#endif
#if 0
/*****************************************************************************/
// Description: Set Param test function
// Global : none
// Author : lisa.lin
// Note :         
/*****************************************************************************/
PUBLIC void DHCPS_Test_SetParam(void)
{
    DHCP_SERVER_CONFIG_T server_param ={0};

    server_param.start_ip = htonl(0xC0A80064);  //172.16.0.20
    server_param.end_ip =   htonl(0xC0A800C8);  //172.16.0.255
    server_param.subnet_mask = htonl(0xFFFFFF00); //255.255.255.0
    server_param.router = htonl(0xC0A80001); //172.16.18.1
    server_param.dns1 = htonl(0x00000000); //172.16.0.134
    server_param.dns2 = htonl(0xC0A80001); //172.16.0.135

 #if 0
    server_param.start_ip = htonl(0xac100014);  //172.16.0.20
    server_param.end_ip =   htonl(0xac1000FF);  //172.16.0.255
    server_param.subnet_mask = htonl(0xFFFFFF00); //255.255.255.0
    server_param.router = htonl(0xac101201); //172.16.18.1
    server_param.dns1 = htonl(0xac100086); //172.16.0.134
    server_param.dns2 = htonl(0xac100087); //172.16.0.135
 #endif
 
    server_param.lease_time = 120; 
    DHCPS_SetServerParam(&server_param);
}


/*****************************************************************************/
// Description: discovery and request packet for random ip and requested lease time
// Global : none
// Author : lisa.lin
// Note :         
/*****************************************************************************/
//random ip,requested lease time
PUBLIC void DHCPS_Test_RandomIP(int type)
{

    TCPIP_PKT_T pk = {0};  
                        
    uint8 mac_src[6] = {0x20, 0x59, 0xa0, 0x00, 0x04, 0x51};
    uint8 mac_dst[6] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff};  


    uint8 discover_data[] = {
        0x01,0x01,0x06,0x00,0x22,0x33,0x44,0x58,0x33,0x32,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x59,0xa0,0x00,
        0x04,0x51,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        0x35,0x01,0x01,0x33,0x04,0x00,0x00,0x30,0x40,0x37,0x04,0x01,0x03,0x06,0x0f,0xff,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
    };

    //request data packet
    uint8 request_data[] = {    
        0x01,0x01,0x06,0x00,0x22,0x33,0x44,0x58,0x33,0x32,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x20,0x59,0xa0,0x00,
        0x04,0x51,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        0x35,0x01,0x03,0x32,0x04,0xc0,0xa8,0x00,0x14,0x01,0x04,0xff,0xff,0xff,0x00,0x03,
        0x04,0xc0,0xa8,0x00,0x01,0x06,0x04,0xac,0x10,0x00,0x86,0x33,0x04,0x00,0x0d,0x2f,
        0x00,0x37,0x04,0x01,0x03,0x06,0x0f,0x36,0x04,0xac,0x10,0x12,0x53,0xff
    };
    /* set packet type: IP or ethernet */
    pk.type = TCPIP_PKTTYPE_ETHER;

    /* set ethernet param */
    SCI_MEMCPY(pk.data.eth.src_mac, mac_src, 6);
    SCI_MEMCPY(pk.data.eth.dst_mac, mac_dst, 6);
    pk.data.eth.type = 0x0800;    /* IP:0x0800; ARP:0x0806 */

    /* set IP param */
    pk.data.eth.data.ip4.src = 0x00000000;  /* 0.0.0.0 */
    pk.data.eth.data.ip4.dst = 0xFFFFFFFF;  /* 255.255.255.255 */
    pk.data.eth.data.ip4.protocol = 0x11;   /* UDP: 0x11; TCP:0x06; ICMP:0x01 */

    /* set UDP param */
    pk.data.eth.data.ip4.data.udp.src_port = 68;
    pk.data.eth.data.ip4.data.udp.dst_port = 67;

    if(type == DHCPDISCOVER)  //recv discover packet
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = discover_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(discover_data);
    }
   
    if(type == DHCPREQUEST)
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = request_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(request_data);

    }
    /* sent packet to TCPIP */
    //TCPIP_RawPktRecv(&pk);    /* TCPIP_RawPktRecv is defined in SoftAP project */

}

/*****************************************************************************/
// Description: discovery and request packet for requested ip
// Global : none
// Author : lisa.lin
// Note :         
/*****************************************************************************/
//requested ip
PUBLIC void DHCPS_Test_RequestIP(int type)
{
    TCPIP_PKT_T pk = {0};
    uint8 mac_src[6] = {0x44, 0x37, 0xE6, 0x06, 0xE0, 0x6A};                       

    uint8 mac_dst[6] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
    //discover data packet (bootp)

    uint8 discover_data[] = {            //|   transation id      ||elapsedtime|
        0x01,0x01,0x06,0x00,0x2b,0x3c,0x5f,0x50,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x44,0x37,0xe6,0x06,
        0xe0,0x6a,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        0x35,0x01,0x01,0x74,0x01,0x01,0x3d,0x07,0x01,0x44,0x37,0xe6,0x06,0xe0,0x6a,0x32,
             
        //|   request ip        |//(0xc0,0xa8,0x00,0x1e)
        0x04,0xc0,0xa8,0x00,0x1e,0x0c,0x09,0x6c,0x69,0x73,0x61,0x6c,0x69,0x6e,0x70,0x63,
        0x3c,0x08,0x4d,0x53,0x46,0x54,0x20,0x35,0x2e,0x30,0x37,0x0b,0x01,0x0f,0x03,0x06,
        0x2c,0x2e,0x2f,0x1f,0x21,0xf9,0x2b,0x2b,0x02,0xdc,0x00,0xff
    };


    //request data packet
    uint8 request_data[] = {    
        0x01,0x01,0x06,0x00,0x2b,0x3c,0x5f,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x44,0x37,0xe6,0x06,
        0xe0,0x6a,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        //|requested ip address|(0xc0,0xa8,0x00,0x1e)
        0x35,0x01,0x03,0x32,0x04,0xc0,0xa8,0x00,0x1e,0x01,0x04,0xff,0xff,0xff,0x00,0x03,
        0x04,0xc0,0xa8,0x00,0x01,0x06,0x04,0xac,0x10,0x00,0x86,0x33,0x04,0x00,0x0d,0x2f,
        0x00,0x37,0x04,0x01,0x03,0x06,0x0f,0x36,0x04,0xac,0x10,0x12,0x53,0xff
    };
    /* set packet type: IP or ethernet */
    pk.type = TCPIP_PKTTYPE_ETHER;

    /* set ethernet param */
    SCI_MEMCPY(pk.data.eth.src_mac, mac_src, 6);
    SCI_MEMCPY(pk.data.eth.dst_mac, mac_dst, 6);
    pk.data.eth.type = 0x0800;    /* IP:0x0800; ARP:0x0806 */

    /* set IP param */
    pk.data.eth.data.ip4.src = 0x00000000;  /* 0.0.0.0 */
    pk.data.eth.data.ip4.dst = 0xFFFFFFFF;  /* 255.255.255.255 */
    pk.data.eth.data.ip4.protocol = 0x11;   /* UDP: 0x11; TCP:0x06; ICMP:0x01 */

    /* set UDP param */
    pk.data.eth.data.ip4.data.udp.src_port = 68;
    pk.data.eth.data.ip4.data.udp.dst_port = 67;

    if(type == DHCPDISCOVER)  //recv discover packet
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = discover_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(discover_data);
    }
   
    if(type == DHCPREQUEST)
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = request_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(request_data);
    }
    /* sent packet to TCPIP */
    //TCPIP_RawPktRecv(&pk);    /* TCPIP_RawPktRecv is defined in SoftAP project */
}

/*****************************************************************************/
// Description: iscovery and request packet for static ip
// Global : none
// Author : lisa.lin
// Note :         
/*****************************************************************************/
PUBLIC void DHCPS_Test_StaticIP(int type)
{

    TCPIP_PKT_T pk = {0};
    uint8 mac_src[6] = {0x00,0x50,0x08,0x10,0xED,0x5F};
    uint8 mac_dst[6] = {0xff, 0xff, 0xff, 0xff, 0xff, 0xff};
    //discover data packet (bootp)

    uint8 discover_data[] = {            //|   transation id      ||elapsedtime|
        0x01,0x01,0x06,0x00,0x2b,0x3c,0x5f,0x50,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x50,0x08,0x10,
        0xed,0x5f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        0x35,0x01,0x01,0x74,0x01,0x01,0x3d,0x07,0x01,0x44,0x37,0xe6,0x06,0xe0,0x6a,0x00,

        //|   request ip        |//(0xc0,0xa8,0x00,0x1e)
        0x00,0x00,0x00,0x00,0x00,0x0c,0x09,0x6c,0x69,0x73,0x61,0x6c,0x69,0x6e,0x70,0x63,
        0x3c,0x08,0x4d,0x53,0x46,0x54,0x20,0x35,0x2e,0x30,0x37,0x0b,0x01,0x0f,0x03,0x06,
        0x2c,0x2e,0x2f,0x1f,0x21,0xf9,0x2b,0x2b,0x02,0xdc,0x00,0xff
    };

    //request data packet
    uint8 request_data[] = {    
        0x01,0x01,0x06,0x00,0x2b,0x3c,0x5f,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x50,0x08,0x10,
        0xed,0x5f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
        0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x63,0x82,0x53,0x63,
        //|requested ip address|()
        0x35,0x01,0x03,0x32,0x04,0xac,0x10,0x01,0x35,0x01,0x04,0xff,0xff,0xff,0x00,0x03,
        0x04,0xc0,0xa8,0x00,0x01,0x06,0x04,0xac,0x10,0x00,0x86,0x33,0x04,0x00,0x0d,0x2f,
        0x00,0x37,0x04,0x01,0x03,0x06,0x0f,0x36,0x04,0xac,0x10,0x12,0x53,0xff
        //|server ip address    |
    };
    /* set packet type: IP or ethernet */
    pk.type = TCPIP_PKTTYPE_ETHER;

    /* set ethernet param */
    SCI_MEMCPY(pk.data.eth.src_mac, mac_src, 6);
    SCI_MEMCPY(pk.data.eth.dst_mac, mac_dst, 6);
    pk.data.eth.type = 0x0800;    /* IP:0x0800; ARP:0x0806 */

    /* set IP param */
    pk.data.eth.data.ip4.src = 0x00000000;  /* 0.0.0.0 */
    pk.data.eth.data.ip4.dst = 0xFFFFFFFF;  /* 255.255.255.255 */
    pk.data.eth.data.ip4.protocol = 0x11;   /* UDP: 0x11; TCP:0x06; ICMP:0x01 */

    /* set UDP param */
    pk.data.eth.data.ip4.data.udp.src_port = 68;
    pk.data.eth.data.ip4.data.udp.dst_port = 67;

    if( type == DHCPDISCOVER )  //recv discover packet
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = discover_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(discover_data);
    }
   
    if( type == DHCPREQUEST )
    {
        /* set UDP data */
        pk.data.eth.data.ip4.data.udp.data_ptr = request_data;
        pk.data.eth.data.ip4.data.udp.data_len = sizeof(request_data);
    }
    /* sent packet to TCPIP */    
    //TCPIP_RawPktRecv(&pk);    /* TCPIP_RawPktRecv is defined in SoftAP project */
}
#endif
